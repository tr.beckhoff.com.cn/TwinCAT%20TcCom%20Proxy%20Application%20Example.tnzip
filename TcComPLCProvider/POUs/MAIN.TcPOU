PROGRAM MAIN
VAR
	m : UDINT;
	
	fbCalc : FB_Calculation('MAIN.fbCalc');
END_VAR

m := m + 1;

END_PROGRAM
